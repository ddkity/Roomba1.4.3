# IAR project Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: CONFIG_PLATFORM_8195A
  ICCARM.CCDiagSuppress: Be006,Pa050,Pa039,Pa089,Pe014,Pe068,Pe089,Pe167,Pe177,Pe186,Pe188,Pe375,Pe550,Pe550,Pe223,Pe549,Pe550
  ICCARM.IExtraOptions: --enum_is_int
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\component\soc\realtek\common\bsp; ..\..\..\component\os\freertos; ..\..\..\component\os\freertos\freertos_v8.1.2\Source\include; ..\..\..\component\os\freertos\freertos_v8.1.2\Source\portable\IAR\ARM_CM3; ..\..\..\component\os\os_dep\include; ..\..\..\component\soc\realtek\8195a\misc\driver; ..\..\..\component\soc\realtek\8195a\misc\os; ..\..\..\component\common\api\network\include; ..\..\..\component\common\api; ..\..\..\component\common\api\platform; ..\..\..\component\common\api\wifi; ..\..\..\component\common\api\wifi\rtw_wpa_supplicant\src; ..\..\..\component\common\application; ..\..\..\component\common\example; ..\..\..\component\common\example\wlan_fast_connect; ..\..\..\component\common\mbed\api; ..\..\..\component\common\mbed\hal; ..\..\..\component\common\mbed\hal_ext; ..\..\..\component\common\mbed\targets\hal\rtl8195a; ..\..\..\component\common\network; ..\..\..\component\common\network\lwip\lwip_v1.4.1\port\realtek\freertos; ..\..\..\component\common\network\lwip\lwip_v1.4.1\src\include; ..\..\..\component\common\network\lwip\lwip_v1.4.1\src\include\lwip; ..\..\..\component\common\network\lwip\lwip_v1.4.1\src\include\ipv4; ..\..\..\component\common\network\lwip\lwip_v1.4.1\port\realtek; ..\..\..\component\common\test; ..\..\..\component\soc\realtek\8195a\cmsis; ..\..\..\component\soc\realtek\8195a\cmsis\device; ..\..\..\component\soc\realtek\8195a\fwlib; ..\..\..\component\soc\realtek\8195a\fwlib\rtl8195a; ..\..\..\component\soc\realtek\8195a\misc\rtl_std_lib\include; ..\..\..\component\common\drivers\wlan\realtek\include; ..\..\..\component\common\drivers\wlan\realtek\src\osdep; ..\..\..\component\common\drivers\wlan\realtek\src\hci; ..\..\..\component\common\drivers\wlan\realtek\src\hal; ..\..\..\component\common\drivers\wlan\realtek\src\hal\OUTSRC; ..\..\..\component\common\drivers\video\realtek\common; ..\..\..\component\common\drivers\i2s; ..\..\..\component\soc\realtek\8195a\fwlib\ram_lib\wlan\realtek\wlan_ram_map\rom; ..\..\..\component\common\network\ssl\polarssl-1.3.8\include; ..\..\..\component\common\network\ssl\mbedtls-2.4.0\include; ..\..\..\component\common\network\ssl\ssl_ram_map\rom; ..\..\..\component\common\utilities; ..\..\..\component\soc\realtek\8195a\misc\rtl_std_lib\include; ..\..\..\component\soc\realtek\8195a\fwlib\ram_lib\usb_otg\include; ..\..\..\component\common\video\v4l2\inc; ..\..\..\component\common\audio; ..\..\..\component\common\media\rtp_codec; ..\..\..\component\common\drivers\usb_class\host\uvc\inc; ..\..\..\component\common\drivers\usb_class\device; ..\..\..\component\common\drivers\usb_class\device\class; ..\..\..\component\common\file_system; ..\..\..\component\common\file_system\fatfs; ..\..\..\component\common\file_system\fatfs\r0.10c\include; ..\..\..\component\common\drivers\sdio\realtek\sdio_host\inc; ..\..\..\component\soc\realtek\8195a\misc\platform; ..\..\..\component\soc\realtek\8195a\misc\fpb; ..\..\..\component\common\media\framework; ..\..\..\component\common\media\codec\mp3; ..\..\..\component\common\media\rtp_codec\mjpeg; ..\..\..\component\common\media\muxer; ..\..\..\component\common\application\mqtt\MQTTClient; ..\..\..\component\common\network\coap\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\inc; ..\..\..\component\soc\realtek\8195a\cmsis; ..\..\..\component\os\os_dep\include; ..\..\..\component\os\freertos\freertos_v8.1.2\Source\include; ..\..\..\component\os\freertos\freertos_v8.1.2\Source\portable\IAR\ARM_CM3
  OBJCOPY.OOCOutputFile: application.srec
  prebuild: CSCRIPT  "..\..\..\component\soc\realtek\8195a\misc\iar_utility\common\prebuild.vbs" "$PROJ_DIR$"
  postbuild: CSCRIPT  "..\..\..\component\soc\realtek\8195a\misc\iar_utility\common\postbuild_img2.vbs" "$TARGET_DIR$" "$PROJ_DIR$" "$CONFIG_NAME$"
  ILINK.IlinkOutputFile: application.axf
  ILINK.IlinkKeepSymbols: bootloader; gImage2EntryFun0; RAM_IMG2_VALID_PATTEN
  ILINK.IlinkIcfFile: image2.icf
  ILINK.IlinkExtraOptions: --redirect malloc=pvPortMalloc; --redirect realloc=pvPortReAlloc; --redirect free=vPortFree
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration UVC (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CONFIG_PLATFORM_8195A; CONFIG_UVC
  ICCARM.CCDiagSuppress: Be006,Pa050,Pa039,Pa089,Pe014,Pe047,Pe068,Pe089,Pe167,Pe177,Pe186,Pe188,Pe375,Pe550,Pe550,Pe223,Pe549,Pe550
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\component\soc\realtek\common\bsp; ..\..\..\component\os\freertos; ..\..\..\component\os\freertos\freertos_v8.1.2\Source\include; ..\..\..\component\os\freertos\freertos_v8.1.2\Source\portable\IAR\ARM_CM3; ..\..\..\component\os\os_dep\include; ..\..\..\component\soc\realtek\8195a\misc\driver; ..\..\..\component\common\api\network\include; ..\..\..\component\common\api; ..\..\..\component\common\api\platform; ..\..\..\component\common\api\wifi; ..\..\..\component\common\api\wifi\rtw_wpa_supplicant\src; ..\..\..\component\common\application; ..\..\..\component\common\example; ..\..\..\component\common\example\wlan_fast_connect; ..\..\..\component\common\mbed\api; ..\..\..\component\common\mbed\hal; ..\..\..\component\common\mbed\hal_ext; ..\..\..\component\common\mbed\targets\hal\rtl8195a; ..\..\..\component\common\network; ..\..\..\component\common\network\lwip\lwip_v1.4.1\port\realtek\freertos; ..\..\..\component\common\network\lwip\lwip_v1.4.1\src\include; ..\..\..\component\common\network\lwip\lwip_v1.4.1\src\include\lwip; ..\..\..\component\common\network\lwip\lwip_v1.4.1\src\include\ipv4; ..\..\..\component\common\network\lwip\lwip_v1.4.1\port\realtek; ..\..\..\component\common\test; ..\..\..\component\soc\realtek\8195a\cmsis; ..\..\..\component\soc\realtek\8195a\cmsis\device; ..\..\..\component\soc\realtek\8195a\fwlib; ..\..\..\component\soc\realtek\8195a\fwlib\rtl8195a; ..\..\..\component\soc\realtek\8195a\misc\rtl_std_lib\include; ..\..\..\component\common\drivers\wlan\realtek\include; ..\..\..\component\common\drivers\wlan\realtek\src\osdep; ..\..\..\component\common\drivers\wlan\realtek\src\hci; ..\..\..\component\common\drivers\wlan\realtek\src\hal; ..\..\..\component\common\drivers\wlan\realtek\src\hal\OUTSRC; ..\..\..\component\common\drivers\video\realtek\common; ..\..\..\component\common\drivers\i2s; ..\..\..\component\soc\realtek\8195a\fwlib\ram_lib\wlan\realtek\wlan_ram_map\rom; ..\..\..\component\common\network\ssl\polarssl-1.3.8\include; ..\..\..\component\common\network\ssl\mbedtls-2.4.0\include; ..\..\..\component\common\network\ssl\ssl_ram_map\rom; ..\..\..\component\common\utilities; ..\..\..\component\soc\realtek\8195a\misc\rtl_std_lib\include; ..\..\..\component\soc\realtek\8195a\fwlib\ram_lib\usb_otg\include; ..\..\..\component\common\video\v4l2\inc; ..\..\..\component\common\audio; ..\..\..\component\common\media\rtp_codec; ..\..\..\component\common\drivers\usb_class\host\uvc\inc; ..\..\..\component\common\file_system\fatfs; ..\..\..\component\common\file_system\fatfs\r0.10c\include; ..\..\..\component\common\drivers\sdio\realtek\sdio_host\inc; ..\..\..\component\soc\realtek\8195a\misc\platform; ..\..\..\component\common\bluetooth; ..\..\..\component\common\media\framework; ..\..\..\component\common\media\codec\mp3; ..\..\..\component\common\media\rtp_codec\mjpeg; ..\..\..\component\common\media\muxer
  ICCARM.IccLang: 0
  ILINK.IlinkExtraOptions: --pi_veneers
configuration INIC-SDIO (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CONFIG_PLATFORM_8195A; CONFIG_INIC
  ICCARM.CCDiagSuppress: as above
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\component\soc\realtek\common\bsp; ..\..\..\component\os\freertos; ..\..\..\component\os\freertos\freertos_v8.1.2\Source\include; ..\..\..\component\os\freertos\freertos_v8.1.2\Source\portable\IAR\ARM_CM3; ..\..\..\component\os\os_dep\include; ..\..\..\component\soc\realtek\8195a\misc\driver; ..\..\..\component\common\api\network\include; ..\..\..\component\common\api; ..\..\..\component\common\api\platform; ..\..\..\component\common\api\wifi; ..\..\..\component\common\api\wifi\rtw_wowlan; ..\..\..\component\common\api\wifi\rtw_wpa_supplicant\src; ..\..\..\component\common\application; ..\..\..\component\common\example; ..\..\..\component\common\example\wlan_fast_connect; ..\..\..\component\common\mbed\api; ..\..\..\component\common\mbed\hal; ..\..\..\component\common\mbed\hal_ext; ..\..\..\component\common\mbed\targets\hal\rtl8195a; ..\..\..\component\common\network; ..\..\..\component\common\network\lwip\lwip_v1.4.1\port\realtek\freertos; ..\..\..\component\common\network\lwip\lwip_v1.4.1\src\include; ..\..\..\component\common\network\lwip\lwip_v1.4.1\src\include\lwip; ..\..\..\component\common\network\lwip\lwip_v1.4.1\src\include\ipv4; ..\..\..\component\common\network\lwip\lwip_v1.4.1\port\realtek; ..\..\..\component\common\test; ..\..\..\component\soc\realtek\8195a\cmsis; ..\..\..\component\soc\realtek\8195a\cmsis\device; ..\..\..\component\soc\realtek\8195a\fwlib; ..\..\..\component\soc\realtek\8195a\fwlib\rtl8195a; ..\..\..\component\common\drivers\wlan\realtek\include; ..\..\..\component\common\drivers\wlan\realtek\src\osdep; ..\..\..\component\common\drivers\wlan\realtek\src\hci; ..\..\..\component\common\drivers\wlan\realtek\src\hal; ..\..\..\component\common\drivers\wlan\realtek\src\hal\OUTSRC; ..\..\..\component\soc\realtek\8195a\fwlib\ram_lib\wlan\realtek\wlan_ram_map\rom; ..\..\..\component\common\network\ssl\polarssl-1.3.8\include; ..\..\..\component\common\network\ssl\ssl_ram_map\rom; ..\..\..\component\common\utilities; ..\..\..\component\soc\realtek\8195a\misc\rtl_std_lib\include; ..\..\..\component\soc\realtek\8195a\fwlib\ram_lib\usb_otg\include; ..\..\..\component\common\video\v4l2\inc; ..\..\..\component\common\media\codec; ..\..\..\component\common\drivers\usb_class\host\uvc\inc; ..\..\..\component\common\file_system\fatfs; ..\..\..\component\common\file_system\fatfs\r0.10c\include; ..\..\..\component\common\drivers\sdio\realtek\sdio_host\inc
  ICCARM.IccLang: 0
  ILINK.IlinkExtraOptions: --pi_veneers
  group ayla/Demo
    ../../../component/common/application/ayla_demo/src/: demo_common.c demo_conf.c demo_ledevb.c demo_sched.c demo_stub.c demo_wifi.c ota.c
  group ayla/libada
    ../../../component/common/ayla/libada/: ada_conf.c ada_err.c client.c client_auth.c client_conf.c client_ota.c client_prop.c conf_json.c dnss.c dnss_util.c lan.c log_page.c notify.c oem.c prop_mgr.c prop_page.c sched.c schedeval.c server_mem.c server_req.c sprop.c sys_conf.c
    ../../../component/common/ayla/libada/al/ameba/: ada_lock.c ameba_conf.c ameba_log.c client_task.c conf_table.c http_client.c notify_task.c sched_conf.c server.c stubs.c
    ../../../component/common/ayla/libada/certs/: ca_certs_der.c
    ../../../component/common/ayla/libada/text/: custom.css.c regtoken.html.c
  group ayla/libadw
    ../../../component/common/ayla/libadw/: adw_wifi_conf.c wifi.c wifi_ameba.c wifi_page.c
    ../../../component/common/ayla/libadw/text/: lock.gif.c refresh.gif.c wifi.html.c wifi.js.c
  group ayla/libayla
    ../../../component/common/ayla/libayla/arch/ameba/: clock.c conf_flash.c malloc.c
    ../../../component/common/ayla/libayla/: clock_fmt.c clock_sw.c clock_utils.c cmd_handle.c conf.c crc.c crc16.c crc8.c endian.c format_mac.c format_string.c hostname_valid.c http.c jsmn_get.c jsmn_iterate.c json_format_string.c log.c log_cmd.c log_conf.c log_io.c lookup_by_name.c lookup_by_val.c parse_argv.c parse_date.c parse_hex.c parse_mac.c parse_url.c timer.c uri_arg_allowed_map.c uri_decode.c uri_encode.c utf8.c xml.c xml_decode.c xml_encode.c
    ../../../component/common/ayla/ext/jsmn/: jsmn.c
  group ayla/libnet
    ../../../component/common/ayla/libnet/ameba/: ipaddr_fmt.c net_mbuf.c net_realtek.c ssl.c
  group ayla-ameba/Demo
    ../../../component/common/application/ayla_demo/src/: led_key.c
  group ayla-ameba/libadw
    ../../../component/common/ayla/libadw/: wifi_ameba_drv.c
  group cmsis
    ../../../component/soc/realtek/8195a/cmsis/device/: system_8195a.c
  group console
    ../../../component/common/api/at_cmd/: atcmd_ethernet.c atcmd_lwip.c atcmd_mp.c atcmd_sys.c atcmd_wifi.c log_service.c
    ../../../component/soc/realtek/8195a/misc/driver/: low_level_io.c rtl_consol.c
  group lib
    ../../../component/soc/realtek/8195a/misc/bsp/lib/common/IAR/: lib_codec.a lib_dct.a lib_googlenest.a lib_hs_uart_redirect.a lib_http.a lib_i2c_redirect.a lib_inic.a lib_mdns.a lib_mmf.a lib_muxer.a lib_p2p.a lib_platform.a lib_rtlstd.a lib_rtsp.a lib_sdcard.a lib_sdiod.a lib_tftp.a lib_usbd.a lib_usbh.a lib_websocket.a lib_wlan.a lib_wps.a lib_xmodem.a
    ../../../component/soc/realtek/8195a/misc/bsp/lib/va0/: rom.a
  group multimedia/audio_driver
    ../../../component/common/drivers/i2s/: alc5640.c alc5651.c alc5660.c alc5679.c alc5680.c sgtl5000.c
  group multimedia/framework/sink_modules
    ../../../component/common/media/framework/mmf_sink_modules/: mmf_sink_i2s.c mmf_sink_mp3.c mmf_sink_mp4.c mmf_sink_rtsp.c mmf_sink_rtsp2.c
  group multimedia/framework/source_modules
    ../../../component/common/media/framework/mmf_source_modules/: mmf_source_aac_file.c mmf_source_h264_file.c mmf_source_i2s_file.c mmf_source_mjpg_file.c mmf_source_pcmu_file.c mmf_source_rtp.c mmf_source_uvc.c
  group network/api
    ../../../component/common/api/: lwip_netconf.c
  group network/api/wifi
    ../../../component/common/api/wifi/: wifi_conf.c wifi_ind.c wifi_promisc.c wifi_simple_config.c wifi_util.c
  group network/api/wifi/rtw_wowlan
    ../../../component/common/api/wifi/rtw_wowlan/: dev_wowlan.c
  group network/api/wifi/rtw_wpa_supplicant
    ../../../component/common/api/wifi/rtw_wpa_supplicant/src/crypto/: tls_polarssl.c
    ../../../component/common/api/wifi/rtw_wpa_supplicant/wpa_supplicant/: wifi_eap_config.c wifi_p2p_config.c wifi_wps_config.c
  group network/app
    ../../../component/soc/realtek/8195a/misc/platform/: ota_8195a.c
    ../../../component/common/api/network/src/: ping_test.c wlan_network.c
    ../../../component/common/utilities/: ssl_client.c ssl_client_ext.c tcptest.c
    ../../../component/common/application/uart_adapter/: uart_adapter.c
  group network/coap
    ../../../component/common/network/coap/: sn_coap_ameba_port.c sn_coap_builder.c sn_coap_header_check.c sn_coap_parser.c sn_coap_protocol.c
  group network/googlenest
    ../../../component/common/application/google/: google_tls.c
  group network/http
    ../../../component/common/network/httpc/: httpc_tls.c
    ../../../component/common/network/httpd/: httpd_tls.c
  group network/lwip
    ../../../component/common/network/dhcp/: dhcps.c
    ../../../component/common/network/sntp/: sntp.c
  group network/lwip/api
    ../../../component/common/network/lwip/lwip_v1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group network/lwip/core
    ../../../component/common/network/lwip/lwip_v1.4.1/src/core/: def.c dhcp.c dns.c init.c lwip_timers.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group network/lwip/core/ipv4
    ../../../component/common/network/lwip/lwip_v1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group network/lwip/netif
    ../../../component/common/network/lwip/lwip_v1.4.1/src/netif/: etharp.c
  group network/lwip/netif/ppp
    ../../../component/common/network/lwip/lwip_v1.4.1/src/netif/ppp/: auth.c chap.c chpms.c fsm.c ipcp.c lcp.c lwip_md5.c magic.c pap.c ppp.c ppp_oe.c randm.c vj.c
  group network/lwip/port
    ../../../component/common/network/lwip/lwip_v1.4.1/port/realtek/freertos/: ethernetif.c sys_arch.c
    ../../../component/common/drivers/wlan/realtek/src/osdep/: lwip_intf.c
  group network/mdns
    ../../../component/common/network/mDNS/: mDNSPlatform.c
  group network/ssl/mbedtls
    ../../../component/common/network/ssl/mbedtls-2.4.0/library/: bignum.c
  group network/ssl/polarssl
    ../../../component/common/network/ssl/polarssl-1.3.8/library/: bignum.c
  group network/wsclient
    ../../../component/common/network/websocket/: wsclient_tls.c
  group os/freertos
    ../../../component/os/freertos/: cmsis_os.c
    ../../../component/os/freertos/freertos_v8.1.2/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group os/freertos/portable
    ../../../component/os/freertos/freertos_v8.1.2/Source/portable/MemMang/: heap_5.c
    ../../../component/os/freertos/freertos_v8.1.2/Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group os/osdep
    ../../../component/os/os_dep/: device_lock.c osdep_service.c tcm_heap.c
    ../../../component/os/freertos/: freertos_service.c
    ../../../component/soc/realtek/8195a/misc/os/: mailbox.c osdep_api.c
  group peripheral/api
    ../../../component/common/mbed/targets/hal/rtl8195a/: analogin_api.c dma_api.c efuse_api.c ethernet_api.c flash_api.c gpio_api.c gpio_irq_api.c i2c_api.c i2s_api.c log_uart_api.c nfc_api.c pinmap.c pinmap_common.c port_api.c pwmout_api.c rtc_api.c serial_api.c sleep.c spdio_api.c spi_api.c sys_api.c timer_api.c us_ticker.c wdt_api.c
    ../../../component/common/drivers/ethernet_mii/: ethernet_mii.c
    ../../../component/common/mbed/common/: us_ticker_api.c wait_api.c
  group peripheral/hal
    ../../../component/soc/realtek/8195a/fwlib/src/: hal_32k.c hal_adc.c hal_gdma.c hal_gpio.c hal_i2c.c hal_i2s.c hal_mii.c hal_nfc.c hal_pcm.c hal_pwm.c hal_sdr_controller.c hal_ssi.c hal_timer.c hal_uart.c
  group peripheral/rtl8195a
    ../../../component/soc/realtek/8195a/fwlib/rtl8195a/src/: rtl8195a_adc.c rtl8195a_gdma.c rtl8195a_gpio.c rtl8195a_i2c.c rtl8195a_i2s.c rtl8195a_mii.c rtl8195a_nfc.c rtl8195a_pwm.c rtl8195a_ssi.c rtl8195a_timer.c rtl8195a_uart.c
  group peripheral/wlan
    ../../../component/common/drivers/wlan/realtek/src/core/option/: rtw_opt_skbuf.c
  group SDRAM
    ../../../component/common/application/ayla_demo/src/: ilifesweeper.c
    ../../../component/common/api/platform/: stdlib_patch.c
  group SDRAM/ssl/mbedtls
    ../../../component/common/network/ssl/mbedtls-2.4.0/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group SDRAM/ssl/polarssl
    ../../../component/common/network/ssl/polarssl-1.3.8/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net.c oid.c padlock.c pbkdf2.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_srv.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group SDRAM/ssl/ssl_ram_map
    ../../../component/common/network/ssl/ssl_ram_map/rom/: rom_ssl_ram_map.c
    ../../../component/common/network/ssl/ssl_ram_map/: ssl_ram_map.c
  group SDRAM/wigadget
    ../../../component/common/application/wigadget/: cloud_link.c shtc1.c wigadget.c
  group user
    ../src/: main.c
  group utilities
    ../../../component/common/application/xmodem/: uart_fw_update.c
    ../../../component/common/utilities/: uart_socket.c webserver.c
  group utilities/example
    ../../../component/common/example/: example_entry.c
    ../../../component/common/example/wlan_fast_connect/: example_wlan_fast_connect.c
  group utilities/FatFs/disk_if
    ../../../component/common/file_system/fatfs/disk_if/src/: sdcard.c usbdisk.c
  group utilities/FatFs/fatfs_ext
    ../../../component/common/file_system/fatfs/fatfs_ext/src/: ff_driver.c
  group utilities/FatFs/r0.10c
    ../../../component/common/file_system/fatfs/r0.10c/src/: diskio.c ff.c
  group utilities/FatFs/r0.10c/option
    ../../../component/common/file_system/fatfs/r0.10c/src/option/: ccsbcs.c
